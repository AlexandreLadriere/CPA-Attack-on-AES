# Keil uVision project DPA-STM32.uvproj, settings and files
target DPA-STM32 (ARM-ADS)
  device: STM32F100RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: DPA-STM32 +hex
  c flags: OneElfS=1 wLevel=2
  c define: STM32F10X_MD_VL, USE_STDPERIPH_DRIVER
  c include: ..\;C:\Keil\ARM\Libraries\CMSIS\CM3\CoreSupport;C:\Keil\ARM\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;C:\Keil\ARM\Libraries\STM32F10x_StdPeriph_Driver\inc;C:\Keil\ARM\Utilities\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group StdPeriph_Driver
    C:/Keil/ARM/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_pwr.c
  group CMSIS
    C:/Keil/ARM/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    C:/Keil/ARM/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group MDK-ARM
    C:/Keil/ARM/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md_vl.s
  group Doc
    ../: readme.txt
  group User
    ../: main.c stm32f10x_it.c
  group STM32vldiscovery
    C:/Keil/ARM/Utilities/: STM32vldiscovery.c
